# Keil uVision project ble-device.uvprojx, settings and files
target Dev board (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL46Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: usb-mouse
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: .\Inc;.\FreeRTOS\Inc;.\Clock\Inc;.\UART\Inc;.\GPIO\Inc;.\printf;.\SPI\Inc;.\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;.\STM32 Compatibility Layer\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Main
    ./: main.c rtos_tasks.c sensor_service.c
  group FreeRTOS
    ./FreeRTOS/: heap_2.c list.c port.c queue.c tasks.c timers.c
  group Clock
    ./Clock/: clock_config.c fsl_clock.c fsl_common.c
  group UART
    ./UART/: uart.c
  group GPIO
    ./GPIO/: gpio.c
  group printf
    ./printf/: tinyprintf.c
  group SPI
    ./SPI/: spi.c
  group STM32_BlueNRG
    ./STM32_BlueNRG/Interface/: bluenrg_itf_template.c
    ./STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
    ./STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: list.c osal.c gp_timer.c
    ./STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group STM32 Compatibility Layer
    ./STM32 Compatibility Layer/: stm32_bluenrg_ble.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
